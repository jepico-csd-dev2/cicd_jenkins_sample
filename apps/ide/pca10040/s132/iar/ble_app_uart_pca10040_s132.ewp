# IAR project ble_app_uart_pca10040_s132.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=7; S132; SOFTDEVICE_PRESENT
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\..\..\..\sdk\config; ..\..\..\..\..\sdk\components; ..\..\..\..\..\sdk\components\ble\ble_advertising; ..\..\..\..\..\sdk\components\ble\ble_dtm; ..\..\..\..\..\sdk\components\ble\ble_link_ctx_manager; ..\..\..\..\..\sdk\components\ble\ble_racp; ..\..\..\..\..\sdk\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_bas; ..\..\..\..\..\sdk\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_cscs; ..\..\..\..\..\sdk\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_dfu; ..\..\..\..\..\sdk\components\ble\ble_services\ble_dis; ..\..\..\..\..\sdk\components\ble\ble_services\ble_gls; ..\..\..\..\..\sdk\components\ble\ble_services\ble_hids; ..\..\..\..\..\sdk\components\ble\ble_services\ble_hrs; ..\..\..\..\..\sdk\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_hts; ..\..\..\..\..\sdk\components\ble\ble_services\ble_ias; ..\..\..\..\..\sdk\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_lbs; ..\..\..\..\..\sdk\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_lls; ..\..\..\..\..\sdk\components\ble\ble_services\ble_nus; ..\..\..\..\..\sdk\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_rscs; ..\..\..\..\..\sdk\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\sdk\components\ble\ble_services\ble_tps; ..\..\..\..\..\sdk\components\ble\common; ..\..\..\..\..\sdk\components\ble\nrf_ble_gatt; ..\..\..\..\..\sdk\components\ble\nrf_ble_qwr; ..\..\..\..\..\sdk\components\ble\peer_manager; ..\..\..\..\..\sdk\components\boards; ..\..\..\..\..\sdk\components\libraries\atomic; ..\..\..\..\..\sdk\components\libraries\atomic_fifo; ..\..\..\..\..\sdk\components\libraries\atomic_flags; ..\..\..\..\..\sdk\components\libraries\balloc; ..\..\..\..\..\sdk\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\sdk\components\libraries\bsp; ..\..\..\..\..\sdk\components\libraries\button; ..\..\..\..\..\sdk\components\libraries\cli; ..\..\..\..\..\sdk\components\libraries\crc16; ..\..\..\..\..\sdk\components\libraries\crc32; ..\..\..\..\..\sdk\components\libraries\crypto; ..\..\..\..\..\sdk\components\libraries\csense; ..\..\..\..\..\sdk\components\libraries\csense_drv; ..\..\..\..\..\sdk\components\libraries\delay; ..\..\..\..\..\sdk\components\libraries\ecc; ..\..\..\..\..\sdk\components\libraries\experimental_section_vars; ..\..\..\..\..\sdk\components\libraries\experimental_task_manager; ..\..\..\..\..\sdk\components\libraries\fds; ..\..\..\..\..\sdk\components\libraries\fifo; ..\..\..\..\..\sdk\components\libraries\fstorage; ..\..\..\..\..\sdk\components\libraries\gfx; ..\..\..\..\..\sdk\components\libraries\gpiote; ..\..\..\..\..\sdk\components\libraries\hardfault; ..\..\..\..\..\sdk\components\libraries\hci; ..\..\..\..\..\sdk\components\libraries\led_softblink; ..\..\..\..\..\sdk\components\libraries\log; ..\..\..\..\..\sdk\components\libraries\log\src; ..\..\..\..\..\sdk\components\libraries\low_power_pwm; ..\..\..\..\..\sdk\components\libraries\mem_manager; ..\..\..\..\..\sdk\components\libraries\memobj; ..\..\..\..\..\sdk\components\libraries\mpu; ..\..\..\..\..\sdk\components\libraries\mutex; ..\..\..\..\..\sdk\components\libraries\pwm; ..\..\..\..\..\sdk\components\libraries\pwr_mgmt; ..\..\..\..\..\sdk\components\libraries\queue; ..\..\..\..\..\sdk\components\libraries\ringbuf; ..\..\..\..\..\sdk\components\libraries\scheduler; ..\..\..\..\..\sdk\components\libraries\sdcard; ..\..\..\..\..\sdk\components\libraries\slip; ..\..\..\..\..\sdk\components\libraries\sortlist; ..\..\..\..\..\sdk\components\libraries\spi_mngr; ..\..\..\..\..\sdk\components\libraries\stack_guard; ..\..\..\..\..\sdk\components\libraries\strerror; ..\..\..\..\..\sdk\components\libraries\svc; ..\..\..\..\..\sdk\components\libraries\timer; ..\..\..\..\..\sdk\components\libraries\twi_mngr; ..\..\..\..\..\sdk\components\libraries\twi_sensor; ..\..\..\..\..\sdk\components\libraries\uart; ..\..\..\..\..\sdk\components\libraries\usbd; ..\..\..\..\..\sdk\components\libraries\usbd\class\audio; ..\..\..\..\..\sdk\components\libraries\usbd\class\cdc; ..\..\..\..\..\sdk\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\sdk\components\libraries\usbd\class\hid; ..\..\..\..\..\sdk\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\sdk\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\sdk\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\sdk\components\libraries\usbd\class\msc; ..\..\..\..\..\sdk\components\libraries\util; ..\..\..\..\..\sdk\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\sdk\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\sdk\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\sdk\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\sdk\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\sdk\components\nfc\ndef\generic\message; ..\..\..\..\..\sdk\components\nfc\ndef\generic\record; ..\..\..\..\..\sdk\components\nfc\ndef\launchapp; ..\..\..\..\..\sdk\components\nfc\ndef\parser\message; ..\..\..\..\..\sdk\components\nfc\ndef\parser\record; ..\..\..\..\..\sdk\components\nfc\ndef\text; ..\..\..\..\..\sdk\components\nfc\ndef\uri; ..\..\..\..\..\sdk\components\nfc\platform; ..\..\..\..\..\sdk\components\nfc\t2t_lib; ..\..\..\..\..\sdk\components\nfc\t2t_parser; ..\..\..\..\..\sdk\components\nfc\t4t_lib; ..\..\..\..\..\sdk\components\nfc\t4t_parser\apdu; ..\..\..\..\..\sdk\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\sdk\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\sdk\components\nfc\t4t_parser\tlv; ..\..\..\..\..\sdk\components\softdevice\common; ..\..\..\..\..\sdk\components\softdevice\s132\headers; ..\..\..\..\..\sdk\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\sdk\components\toolchain\cmsis\include; ..\..\..\..\..\sdk\external\fprintf; ..\..\..\..\..\sdk\external\segger_rtt; ..\..\..\..\..\sdk\external\utf_converter; ..\..\..\..\..\sdk\integration\nrfx; ..\..\..\..\..\sdk\integration\nrfx\legacy; ..\..\..\..\..\sdk\modules\nrfx; ..\..\..\..\..\sdk\modules\nrfx\drivers\include; ..\..\..\..\..\sdk\modules\nrfx\hal; ..\..\..\..\..\sdk\modules\nrfx\mdk; ..\config; ..\..\..\..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mpu; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\components\libraries\stack_guard; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\components\nfc\platform; ..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\external\utf_converter; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: ble_app_uart_pca10040_s132.hex
  ILINK.IlinkOutputFile: ble_app_uart_pca10040_s132.out
  ILINK.IlinkIcfFile: ble_app_uart_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../src/: common.c main.c method.c sdk_config.h
  group Board Definition
    ../../../../../sdk/components/boards/: boards.c
  group Board Support
    ../../../../../sdk/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group None
    ../../../../../sdk/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_BLE
    ../../../../../sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../sdk/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../sdk/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../../../../sdk/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../sdk/modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../../../sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../sdk/components/libraries/button/: app_button.c
    ../../../../../sdk/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../sdk/components/libraries/fifo/: app_fifo.c
    ../../../../../sdk/components/libraries/scheduler/: app_scheduler.c
    ../../../../../sdk/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../sdk/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../sdk/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../sdk/components/libraries/atomic/: nrf_atomic.c
    ../../../../../sdk/components/libraries/balloc/: nrf_balloc.c
    ../../../../../sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../sdk/components/libraries/memobj/: nrf_memobj.c
    ../../../../../sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../sdk/components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../sdk/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../sdk/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../../../../sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group UTF8/UTF16 converter
    ../../../../../sdk/external/utf_converter/: utf.c
